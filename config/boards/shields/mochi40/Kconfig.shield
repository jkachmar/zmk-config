## config/boards/shields/mochi40/Kconfig.shield
```kconfig
# Aidan Smith (2021)
# SPDX-License-Identifier: MIT

config SHIELD_mochi40
	def_bool $(shields_list_contains,mochi40)
```
